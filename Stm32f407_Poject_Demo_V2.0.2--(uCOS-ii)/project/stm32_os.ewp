# IAR project stm32_os.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\APP\Header; ..\BSP\Driver\gpio; ..\BSP\Driver\sysclk; ..\BSP\Driver\pdebug; ..\BSP\STM32F4xx_HAL_Driver\Inc; ..\BSP\STM32F4xx_HAL_Driver\Inc\Legacy; ..\CMSIS\STM32F4xx\Include; ..\BSP; ..\OS2\uC-CPU; ..\OS2\uC-LIB; ..\OS2\uCOS-II\Ports; ..\OS2\uCOS-II\Source; ..\BSP\bsp_os
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_os.bin
  ILINK.IlinkOutputFile: stm32_os.out
  ILINK.IlinkIcfFile: F:\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP/Header
    ../APP/Header/: app_cfg.h comm_types.h cpu_cfg.h device_term.h device_wdog.h includes.h lib_cfg.h os_cfg.h stm32f4xx_hal_conf.h
  group APP/Source
    ../APP/Source/: app.c app_hooks.c device_term.c device_wdog.c
  group BSP
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c cpu_bsp.c
  group BSP/Driver/gpio
    ../BSP/Driver/gpio/: gpio.c gpio.h
  group BSP/Driver/pdebug
    ../BSP/Driver/pdebug/: pdebug.c pdebug.h
  group BSP/Driver/sysclk
    ../BSP/Driver/sysclk/: sysclk.c sysclk.h
  group BSP/Driver/uart
    ../BSP/Driver/uart/: uart.c uart.h uart_recv.c uart_recv.h
  group BSP/Driver/wdog
    ../BSP/Driver/wdog/: wdog.c wdog.h
  group BSP/IAR
    ../BSP/IAR/: cstartup.c
  group BSP/os
    ../BSP/bsp_os/: bsp_os.c bsp_os.h
  group BSP/STM32F4xx_HAL_Driver
    ../BSP/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
  group CMSIS
    ../CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group OS2/uC-CPU
    ../OS2/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group OS2/uC-LIB
    ../OS2/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group OS2/uCOS-II/Ports
    ../OS2/uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group OS2/uCOS-II/Source
    ../OS2/uCOS-II/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
